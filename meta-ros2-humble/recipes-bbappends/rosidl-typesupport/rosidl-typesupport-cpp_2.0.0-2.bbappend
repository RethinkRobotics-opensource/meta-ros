DEPENDS += " \
    rosidl-cmake \
"

inherit distutils3-base