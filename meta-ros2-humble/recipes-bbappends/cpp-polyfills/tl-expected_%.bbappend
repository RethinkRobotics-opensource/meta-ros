# generated recipe sets it to Creative-Commons-Zero-v1.0-Universal
# yocto want CC0-1.0
LICENSE = "CC0-1.0"